Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 1 мини с пс.IFC
Time: 2025-11-25T14:14:18
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 1 мини.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[30]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[31]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[32]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 1 мини.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
